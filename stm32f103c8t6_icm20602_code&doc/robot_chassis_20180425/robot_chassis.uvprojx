# Keil uVision project robot_chassis.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: robot_chassis
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: SRC/HARDWARE;SRC/SYSTEM;SRC/USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./SRC/USER/: robot_chassis.c AHRS.c AHRS.h
  group SYSTEM
    ./SRC/SYSTEM/: sys.c sys.h usart.c usart.h time.c time.h delay.c delay.h
  group HARDWARE
    ./SRC/HARDWARE/: led.c led.h mpu9250.c mpu9250.h mpui2c.c mpui2c.h oled.c oled.h key.c key.h exti.h exti.c motor.h motor.c encoder.c encoder.h adc.h adc.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
